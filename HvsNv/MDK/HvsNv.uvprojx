# Keil uVision project HvsNv.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HvsNv1-2-2 +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\Source;..\Source\CMSIS;..\Source\FWlib\inc;..\Source\UCOSIII\uC-CPU;..\Source\UCOSIII\uC-LIB;..\Source\UCOSIII\uCOS-III\Ports;..\Source\UCOSIII\uCOS-III\Source;..\Source\UCOSIII\config;..\Source\UCOSIII\bsp;..\Source\LwIP\src\include;..\Source\LwIP\src\include\ipv4;..\Source\LwIP\port;..\Source\LwIP\port\Standalone;..\Source\ETH;..\Source\NET;..\Source\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../Source/: main.c led.c stm32f4xx_it.c comm.c stmflash.c mulcast.c
    ./: relay.c temperatue.c adc.c
  group CMSIS
    ../Source/CMSIS/: system_stm32f4xx.c startup_stm32f40xx.s
  group FWlib
    ../Source/FWlib/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_adc.c
  group UCOS_CPU
    ../Source/UCOSIII/uC-CPU/: cpu_core.c cpu_a.asm cpu_c.c
  group UCOS_LIB
    ../Source/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group UCOS_CORE
    ../Source/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_PORT
    ../Source/UCOSIII/uCOS-III/Ports/: os_cpu_c.c os_cpu_a.asm
    ../Source/UCOSIII/bsp/: os_cpu_bsp.c
  group UCOS_CONFIG
    ../Source/UCOSIII/config/: app_cfg.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h os_app_hooks.h os_app_hooks.c
  group LWIP_API
    ../Source/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP_CORE
    ../Source/LwIP/src/core/: udp.c def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c
  group LWIP_IPV4
    ../Source/LwIP/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_NETIF
    ../Source/LwIP/src/netif/: etharp.c
  group LWIP_PORT
    ../Source/LwIP/port/Standalone/: ethernetif.c
    ../Source/LwIP/port/: sys_arch_ucos3.c
  group ETH_NET
    ../Source/NET/: lwipopts.h net_config.h netconf.c udpecho.c tcpecho.c
    ../Source/ETH/: eth_driver.c user_stm32f4x7_eth.c
  group DOC
    ../Source/: readme.txt
